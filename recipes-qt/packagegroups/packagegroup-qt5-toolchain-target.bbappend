redepends_tools = "qttools qtools-dev qttools-tools qttools-mkspecs qttools-static-dev"

RDEPENDS_${PN} += " qtwebengine"